# Keil uVision project pa3_main.uvproj, settings and files
target IAP15F2K61S2 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FFF) CLOCK(11059200) MODP2
  output: pa3_main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\common
  asm include: ..\common
  group Source Group 1
    ./src/: main.c
    ../common/: led.c display.c pcf8591.c ds18b20.c uart.c delay.c
