# Keil uVision project pa1_main.uvproj, settings and files
target STC89C54RDPlus (MCS-51)
  device: 8XC52 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000) MODP2
  output: pa1_main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\common
  asm include: ..\common
  group Source Group 1
    ./src/: main.c
    ../common/: i8255.c led.c display.c adc0809.c dht11.c uart.c delay.c
